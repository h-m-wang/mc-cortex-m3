# Keil uVision project project.uvprojx, settings and files
target Cpu_bin (ARM-ADS)
  device: ARMCM3 ARM
  pack: ARM.CMSIS.4.3.0
  cpu: IROM(0x00000000,0x40000) IRAM(0x20000000,0x20000) CPUTYPE("Cortex-M3") CLOCK(12000000) ESEL ELITTLE
  output: output
  AfterMake: D:\Program Files (x86)\Keil_v5\ARM\ARMCC\bin\fromelf.exe --bin -o ./bin/output.bin ./Obj/output.axf
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: STM32F10X_HD, USE_STDPERIPH_DRIVER
  c include: ..\..\Libraries\CMSIS\Core\CM3;..\..\Libraries\STM32F10x_StdPeriph_Driver\inc;..\..\Source\inc;..\..\Driver\inc
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x20000
  group User
    ../../Source/src/: main.c SCM3_it.c retarget.c
  group RVMDK
    ../../Source/src/: startup_SCM3.s
  group CMSIS
    ../../Source/src/: core_cm3.c
  group Driver
    ../../Driver/src/: hyhwUart.c hyhwTimer.c hyhwGPIO.c hyhwDma.c hyhwSpi.c hyhwWatchdog.c hyhw_SpiFlash.c sys_ctl.c
target Cpu_debug (ARM-ADS)
  device: ARMCM3 ARM
  pack: ARM.CMSIS.4.3.0
  cpu: IROM(0x00000000,0x80000) IRAM(0x20000000,0x20000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: output
  AfterMake: C:\Keil_v5\ARM\ARMCC\bin\fromelf.exe --bin -o ./bin/firmware.bin ./Obj/output.axf
  c flags: Optim=1 OneElfS=1 wLevel=2
  c include: ..\..\Source\inc;..\..\Driver\inc
  library: MicroLIB
  memory RVCT4: ROM 0x20000000 size 0x4fff
  memory RVCT9: RAM 0x20005000 size 0x5fff
target Cpu_flash (ARM-ADS)
  device: ARMCM3 ARM
  pack: ARM.CMSIS.4.3.0
  cpu: as above
  output: output
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: STM32F10X_HD, USE_STDPERIPH_DRIVER
  c include: ..\..\Libraries\CMSIS\Core\CM3;..\..\Libraries\STM32F10x_StdPeriph_Driver\inc;..\..\Source\inc
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x20000
